# Repository calico21/Torque-Vectoring-eRacing

File README.md:

# TeR_ECU
TeR Electronic Control Unit, which handles the behaivour of the cars dynamic system while gathering all the sensor and data neccesary for operation through its inputs and communication buses.

## Features
- STM32F405VGTx Microcontroller (Cortex™-M4 Core@168mHz with FPU)
- USB For Diagnosis Operation
- 2x CAN 2.0 For its communication with the Powertrain CAN and main sensors CAN
- NEO M9N GPS modules from u-blox, for determining cars position (Posibility to drive an active Antenna)
- 9DOF IMU consisting in Accelerometer, Gyroscope and Magnetometer for accurate posting and torque algorithms
- 4 Digital Inputs (0V-24V Range)
- 4 PWM Outputs(3.3V), for servo control, including actuators
- 4 Analog Inputs (0V-3.3V) Possibility of configurable Input divider
- 4 Digital Outputs(0V-24V) High side mosfet drivers
- 2 WS2812 RGB Led Channels using integrated SPI for FS-Spain LightShow Acceleration

## KiCad design HARDWARE/TeR_ECU/TeR_ECU.kicad_pcb

Parts:
D1: ERR; LED_0603_1608Metric
D2: IMU; LED_0603_1608Metric
D3: SYS; LED_0603_1608Metric
D4: PWR; LED_0603_1608Metric
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_ISO7380_Pad_TopBottom
IC1: MX34040NF2; Mouser Part Number 656-MX34040NF2
R1, R2, R3, R4: 120R; R_0603_1608Metric

Connections:
+3.3V: IC1.21, IC1.22, IC1.23, IC1.24, R4.1; also elsewhere on the board
+5V: IC1.25, IC1.26, IC1.27, IC1.28; also elsewhere on the board
+24V: IC1.29, IC1.30, IC1.31, IC1.32; also elsewhere on the board
/AIN0: IC1.1; also elsewhere on the board
/AIN1: IC1.2; also elsewhere on the board
/AIN2: IC1.3; also elsewhere on the board
/AIN3: IC1.4; also elsewhere on the board
/DIN0: IC1.5; also elsewhere on the board
/DIN1: IC1.6; also elsewhere on the board
/DIN2: IC1.7; also elsewhere on the board
/DIN3: IC1.8; also elsewhere on the board
/DOUT0: IC1.9; also elsewhere on the board
/DOUT1: IC1.10; also elsewhere on the board
/DOUT2: IC1.11; also elsewhere on the board
/DOUT3: IC1.12; also elsewhere on the board
/ERR_LED: R1.1; also elsewhere on the board
/IMU_LED: R2.1; also elsewhere on the board
/LED1: IC1.17; also elsewhere on the board
/LED2: IC1.18; also elsewhere on the board
/PWM0: IC1.13; also elsewhere on the board
/PWM1: IC1.14; also elsewhere on the board
/PWM2: IC1.15; also elsewhere on the board
/PWM3: IC1.16; also elsewhere on the board
/SC_IN: IC1.19; also elsewhere on the board
/SC_OUT: IC1.20; also elsewhere on the board
/SYS_LED: R3.1; also elsewhere on the board
GND: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), H1.1 (1_1), H2.1 (1_1), H3.1 (1_1), H4.1 (1_1), IC1.33, IC1.34, IC1.35, IC1.36, IC1.37, IC1.38, IC1.39, IC1.40, IC1.41, IC1.42; also elsewhere on the board
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.2
unnamed: D3.2 (A), R3.2
unnamed: D4.2 (A), R4.2

Notes on the sheet:
LEDS

Parts:
C1, C41: 100n; C_0603_1608Metric
C2: 4.7nF; C_0603_1608Metric
C3, C4: 10p; C_0603_1608Metric
D7: NUP2105L; SOT-23
FL1: ACT45B-510-2P-TL003; ACT45B1012PTL003; Mouser Part Number 810-ACT45B5102PTL003
JP1: SolderJumper_3_Open; SolderJumper-3_P1.3mm_Open_Pad1.0x1.5mm
R7, R8: 60R; R_0603_1608Metric
U1: TCAN3403DR-Q1; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3.3V: C1.2, C41.1, U1.3 (VCC), U1.5 (SHDNVIO); also elsewhere on the board
/CAN_MAIN/CAN+: C3.2, FL1.2, R7.1; also elsewhere on the board
/CAN_MAIN/CAN-: C4.1, FL1.1, R8.2; also elsewhere on the board
/CAN_MAIN/CAN_RX: U1.4 (RXD); also elsewhere on the board
/CAN_MAIN/CAN_TX: U1.1 (TXD); also elsewhere on the board
GND: C1.1, C2.2, C3.1, C4.2, C41.2, D7.3 (A), U1.2 (GND), U1.8 (STB); also elsewhere on the board
unnamed: JP1.1 (A), R7.2
unnamed: JP1.3 (B), R8.1
unnamed: C2.1, JP1.2 (C)
unnamed: D7.2 (K), FL1.3, U1.7 (CANH)
unnamed: D7.1 (K), FL1.4, U1.6 (CANL)

Parts of its further copies:
C5, C43: 100n; C_0603_1608Metric
C6: 4.7nF; C_0603_1608Metric
C7, C8: 10p; C_0603_1608Metric
D8: NUP2105L; SOT-23
FL2: ACT45B-510-2P-TL003; ACT45B1012PTL003; Mouser Part Number 810-ACT45B5102PTL003
JP2: SolderJumper_3_Open; SolderJumper-3_P1.3mm_Open_Pad1.0x1.5mm
R9, R10: 60R; R_0603_1608Metric
U2: TCAN3403DR-Q1; SOIC-8_3.9x4.9mm_P1.27mm

Connections of its further copies:
+3.3V: C5.2, C43.1, U2.3 (VCC), U2.5 (SHDNVIO); also elsewhere on the board
/CAN_POWERTRAIN/CAN+: C7.2, FL2.2, R9.1; also elsewhere on the board
/CAN_POWERTRAIN/CAN-: C8.1, FL2.1, R10.2; also elsewhere on the board
/CAN_POWERTRAIN/CAN_RX: U2.4 (RXD); also elsewhere on the board
/CAN_POWERTRAIN/CAN_TX: U2.1 (TXD); also elsewhere on the board
GND: C5.1, C6.2, C7.1, C8.2, C43.2, D8.3 (A), U2.2 (GND), U2.8 (STB); also elsewhere on the board
unnamed: JP2.1 (A), R9.2
unnamed: JP2.3 (B), R10.1
unnamed: C6.1, JP2.2 (C)
unnamed: D8.2 (K), FL2.3, U2.7 (CANH)
unnamed: D8.1 (K), FL2.4, U2.6 (CANL)

Notes on the sheet:
Can Frontend 1- Terminación Split Amortiguada con un cap que filtra el desbalance 2- Bobina de Modo Cómún para filtrar el ruido de modo común 3- Diodo de proteción para sobretensiones
Can Bus transceiver
Actualizado. Modificar a C5 y C9 o se deja en C41 y C43?
Actualizado

Parts:
D21, D22, D23, D24: PTVS26VZ1USK; Nexperia_DSN1608-2_1.6x0.8mm
Q1, Q2, Q3, Q4: ZXMN3F30FH; SOT-23
R27, R28, R31, R33: 6R; R_0603_1608Metric
R29, R30, R32, R34: 1K; R_0603_1608Metric

Connections:
/DOUT0: D21.1 (K), Q1.3 (D); also elsewhere on the board
/DOUT1: D22.1 (K), Q3.3 (D); also elsewhere on the board
/DOUT2: D23.1 (K), Q4.3 (D); also elsewhere on the board
/DOUT3: D24.1 (K), Q2.3 (D); also elsewhere on the board
/D_OUTPUTS/DO0: R27.2, R29.1; also elsewhere on the board
/D_OUTPUTS/DO1: R31.2, R32.1; also elsewhere on the board
/D_OUTPUTS/DO2: R33.2, R34.1; also elsewhere on the board
/D_OUTPUTS/DO3: R28.2, R30.1; also elsewhere on the board
GND: D21.2 (A), D22.2 (A), D23.2 (A), D24.2 (A), Q1.2 (S), Q2.2 (S), Q3.2 (S), Q4.2 (S), R29.2, R30.2, R32.2, R34.2; also elsewhere on the board
unnamed: Q1.1 (G), R27.1
unnamed: Q2.1 (G), R28.1
unnamed: Q3.1 (G), R31.1
unnamed: Q4.1 (G), R33.1

Parts:
U11: AT24CS02-STUM; SOT-23-5

Connections:
+3.3V: U11.4 (VCC); also elsewhere on the board
/MICRO_F4/SCL_2: U11.1 (SCL); also elsewhere on the board
/MICRO_F4/SDA_2: U11.3 (SDA); also elsewhere on the board
GND: U11.2 (GND), U11.5 (WP); also elsewhere on the board

Notes on the sheet:
ADRESS: WRITE 0xA0 READ 0xA1
Eeprom to store things like - Sched Gain pid tables - Driven Km - Driving mode configs - Images for LEDS
R/W Mode

Parts:
D5, D32: PTVS7V5Z1USK; Nexperia_DSN1608-2_1.6x0.8mm
R5, R6: 100R; R_0603_1608Metric

Connections:
/LED1: D32.1 (K), R5.1; also elsewhere on the board
/LED2: D5.1 (K), R6.1; also elsewhere on the board
/LEDS/LED1_SPI: R5.2; also elsewhere on the board
/LEDS/LED2_SPI: R6.2; also elsewhere on the board
GND: D5.2 (A), D32.2 (A); also elsewhere on the board

Notes on the sheet:
Just limit output current and protect SPI line It is meant to drive the WS2812 using SPI@2.5mbps which is conformant with the protocol and can exploit the periferal efficency compared to bitbanging with a timer

Parts:
C17: 10uF; C_1210_3225Metric
C18: 0,1uF; C_0603_1608Metric
C19, C20, C21, C22, C23, C25, C26: 100nF; C_0603_1608Metric
C24, C27: 15pf; C_0603_1608Metric
C28: 100nF; C_0402_1005Metric
C29: 10uF; C_0402_1005Metric
C30, C31: 30p; C_0603_1608Metric
C32, C33: 2.2uF; C_0805_2012Metric
FB1: 120R; L_0805_2012Metric
J3: DEBUG; PinHeader_2x05_P1.27mm_Vertical
R35, R36, R37: 100k; R_0603_1608Metric
R38, R39, R40, R42, R43: 10k; R_0603_1608Metric
SW1: RST; SW_SPST_PTS810
SW2: BOOT0; SW_SPST_PTS810
U6: STM32F405VGTx; LQFP-100_14x14mm_P0.5mm
Y1: ECX-12R; Crystal_SMD_2012-2Pin_2.0x1.2mm
Y2: ECS-250-20-33-CKM-TR; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3.3V: C17.1, C19.1, C20.1, C21.1, C22.1, C23.1, C25.1, C26.1, FB1.2, J3.1 (VTref), R35.1, R37.1, R39.1, R40.1, R42.1, R43.1, SW2.1 (A), U6.6 (VBAT), U6.11 (VDD), U6.19 (VDD), U6.28 (VDD), U6.50 (VDD), U6.75 (VDD), U6.100 (VDD); also elsewhere on the board
+3.3VADC: C28.1, C29.1, FB1.1, U6.22 (VDDA)
/CAN_MAIN/CAN_RX: U6.51 (PB12); also elsewhere on the board
/CAN_MAIN/CAN_TX: U6.52 (PB13); also elsewhere on the board
/CAN_POWERTRAIN/CAN_RX: U6.81 (PD0); also elsewhere on the board
/CAN_POWERTRAIN/CAN_TX: U6.82 (PD1); also elsewhere on the board
/D_OUTPUTS/DO0: U6.2 (PE3); also elsewhere on the board
/D_OUTPUTS/DO1: U6.1 (PE2); also elsewhere on the board
/D_OUTPUTS/DO2: U6.98 (PE1); also elsewhere on the board
/D_OUTPUTS/DO3: U6.97 (PE0); also elsewhere on the board
/ERR_LED: U6.36 (PB1); also elsewhere on the board
/GPS/RX: U6.68 (PA9); also elsewhere on the board
/GPS/TX: U6.69 (PA10); also elsewhere on the board
/IMU_LED: U6.37 (PB2); also elsewhere on the board
/INPUTS/A0: U6.25 (PA2); also elsewhere on the board
/INPUTS/A1: U6.26 (PA3); also elsewhere on the board
/INPUTS/A2: U6.23 (PA0); also elsewhere on the board
/INPUTS/A3: U6.24 (PA1); also elsewhere on the board
/INPUTS/D0: U6.5 (PE6); also elsewhere on the board
/INPUTS/D1: U6.4 (PE5); also elsewhere on the board
/INPUTS/D2: U6.3 (PE4); also elsewhere on the board
/INPUTS/D3: U6.38 (PE7); also elsewhere on the board
/LEDS/LED1_SPI: U6.32 (PA7); also elsewhere on the board
/LEDS/LED2_SPI: U6.18 (PC3); also elsewhere on the board
/MICRO_F4/BOOT0: R38.1, SW2.2 (B), U6.94 (BOOT0)
/MICRO_F4/HSE_IN: C30.1, U6.12 (PH0), Y2.1
/MICRO_F4/HSE_OUT: C31.1, U6.13 (PH1), Y2.3
/MICRO_F4/LSE_IN: C24.1, U6.8 (PC14), Y1.1
/MICRO_F4/LSE_OUT: C27.1, U6.9 (PC15), Y1.2
/MICRO_F4/NRST: C18.1, J3.10 (~RESET), R35.2, SW1.2 (B), U6.14 (NRST)
/MICRO_F4/SCL_1: R39.2, U6.92 (PB6); also elsewhere on the board
/MICRO_F4/SCL_2: R42.2, U6.47 (PB10); also elsewhere on the board
/MICRO_F4/SC_EN: U6.96 (PB9); also elsewhere on the board
/MICRO_F4/SDA_1: R40.2, U6.93 (PB7); also elsewhere on the board
/MICRO_F4/SDA_2: R43.2, U6.48 (PB11); also elsewhere on the board
/MICRO_F4/SWCLK: J3.4 (SWCLK/TCK), R36.1, U6.76 (PA14)
/MICRO_F4/SWDIO: J3.2 (SWDIO/TMS), R37.2, U6.72 (PA13)
/MICRO_F4/SWO: J3.6 (SWO/TDO), U6.89 (PB3)
/MICRO_F4/T3_CH1: U6.63 (PC6); also elsewhere on the board
/MICRO_F4/T3_CH2: U6.64 (PC7); also elsewhere on the board
/MICRO_F4/T3_CH3: U6.65 (PC8); also elsewhere on the board
/MICRO_F4/T3_CH4: U6.66 (PC9); also elsewhere on the board
/MICRO_F4/USB_D+: U6.71 (PA12); also elsewhere on the board
/MICRO_F4/USB_D-: U6.70 (PA11); also elsewhere on the board
/MICRO_F4/VREF+: U6.21 (VREF+)
/SYS_LED: U6.35 (PB0); also elsewhere on the board
GND: C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C25.2, C26.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, J3.3 (GND), J3.5 (GND), J3.9 (GNDDetect), R36.2, R38.2, SW1.1 (A), U6.10 (VSS), U6.20 (VSSA), U6.27 (VSS), U6.74 (VSS), U6.99 (VSS), Y2.2, Y2.4; also elsewhere on the board
unnamed: C32.1, U6.49 (VCAP_1)
unnamed: C33.1, U6.73 (VCAP_2)

Notes on the sheet:
I2C_2
Calculated: - Cs = 5pf - Cl = 20pf - C1=C2= 30pf
Debug Connector
when adc filtering is needed, recommended to add 100nF+10uF(low ESR) cap as well as a ferrite bead and tie to vdd
6x100nF vdd 1x100nF vbat 1x10uF low ESR for the package as close as possible to one vdd pin
BOOT
PSU DECOUPLING
RST
Calculated: - Cs = 5pf - Cl = 12.5pf - C1=C2= 15pf
LSE
I2C_1
ADC SUPPLY
HSE

Parts:
C40: 10p; C_0603_1608Metric
C42: 10n; C_0402_1005Metric
D25: TPS; LED_0603_1608Metric
D26: ESD9101P2T5G; SODFL1006X40N; Manufacturer_Part_Number ESD9101P2T5G; Mouser Part Number 863-ESD9101P2T5G
J5: GPS_ANT; SMA_Amphenol_132289_EdgeMount
JP3: EN_USB; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
L2: 27nH; L_0402_1005Metric
R41: 100k; R_0603_1608Metric
R44, R53: 27R; R_0603_1608Metric
R45: 100R; R_0603_1608Metric
R46: 10R; R_0402_1005Metric
TP1: GPS_SFBOOT; TestPoint_Pad_1.0x1.0mm
TP2: USB+; TestPoint_Pad_1.0x1.0mm
TP3: USB-; TestPoint_Pad_1.0x1.0mm
U10: NEO-M9N; ublox_NEO

Connections:
+3.3V: C40.1, JP3.2 (B), U10.2 (D_SEL), U10.22 (V_BCKP), U10.23 (VCC); also elsewhere on the board
/GPS/RX: U10.21 (RXD/SPI_MOSI); also elsewhere on the board
/GPS/TX: U10.20 (TXD/SPI_MISO); also elsewhere on the board
GND: C40.2, C42.2, D26.2 (A), J5.2 (Ext), R41.2, R45.2, U10.10 (GND), U10.12 (GND), U10.13 (GND), U10.24 (GND); also elsewhere on the board
unnamed: C42.1, L2.1, R46.1
unnamed: D25.2 (A), U10.3 (TIMEPULSE)
unnamed: D25.1 (K), R45.1
unnamed: D26.1 (K), J5.1 (In), L2.2, U10.11 (RF_IN)
unnamed: JP3.1 (A), R41.1, U10.7 (VDD_USB)
unnamed: R44.1, TP3.1 (1_1)
unnamed: R53.2, TP2.1 (1_1)
unnamed: R44.2, U10.5 (USB_DM)
unnamed: R53.1, U10.6 (USB_DP)
unnamed: R46.2, U10.9 (VCC_RF)
unnamed: TP1.1 (1_1), U10.1 (~SAFEBOOT)

Notes on the sheet:
BIAS-T

Parts:
J1: 76825-0006; 768250006; Mouser Part Number 538-76825-0006

Connections:
24_VIN: J1.4; also elsewhere on the board
/CAN_MAIN/CAN+: J1.1; also elsewhere on the board
/CAN_MAIN/CAN-: J1.2; also elsewhere on the board
/LV_CAN/shield: J1.3
GND: J1.5; also elsewhere on the board

Parts of its further copies:
J2: 76825-0006; 768250006; Mouser Part Number 538-76825-0006

Connections of its further copies:
24_VIN: J2.4; also elsewhere on the board
/CAN_POWERTRAIN/CAN+: J2.1; also elsewhere on the board
/CAN_POWERTRAIN/CAN-: J2.2; also elsewhere on the board
/PowerTrain/shield: J2.3
GND: J2.5; also elsewhere on the board

Notes on the sheet:
Output o Bidireccional?
Cableado de corriente acorde al estandar POE plantear el uso de 3 y 6 como conductores para mas Potencia
Actualizado

Schematic: IMU.kicad_sch, TeR_ECU

Parts:
C34, C35, C37, C38: 100n; C_0603_1608Metric
C36: 1u; C_0603_1608Metric
C39: 10u; C_0603_1608Metric
U8: ASM330LHH; LGA-14L_2P5X3X0P83_STM-L
U9: LIS3MDL; LGA-12_2x2mm_P0.5mm

Connections:
+3.3V: C34.1, C36.2, C37.2, C38.1, C39.2, U8.2 (RES), U8.3 (RES), U8.5 (VDD_IO), U8.8 (VDD), U8.12 (CS), U9.5 (Vdd), U9.6 (Vdd_IO), U9.10 (~CS); also elsewhere on the board
/MICRO_F4/SCL_1: U8.13 (SCL), U9.1 (SCL/SPC); also elsewhere on the board
/MICRO_F4/SDA_1: U8.14 (SDA), U9.11 (SDA/SDI/SDO); also elsewhere on the board
GND: C34.2, C35.2, C36.1, C37.1, C38.2, C39.1, U8.1 (SDO/SA0), U8.6 (GND), U8.7 (GND), U9.2 (GND), U9.3 (GND), U9.9 (SDO/SA1), U9.12 (GND); also elsewhere on the board
unnamed: C35.1, U9.4 (C1)

Notes on the sheet:
Address 0b1101010
Address 0b0011100
Accel + Gyro
Magnetometer

Schematic: PWM.kicad_sch, TeR_ECU

Parts:
D27, D28, D29, D30: PTVS26VZ1USK; Nexperia_DSN1608-2_1.6x0.8mm
R47, R48, R49, R50: 100R; R_0603_1608Metric

Connections:
/MICRO_F4/T3_CH1: R47.2; also elsewhere on the board
/MICRO_F4/T3_CH2: R48.2; also elsewhere on the board
/MICRO_F4/T3_CH3: R49.2; also elsewhere on the board
/MICRO_F4/T3_CH4: R50.2; also elsewhere on the board
/PWM0: D27.1 (K), R47.1; also elsewhere on the board
/PWM1: D28.1 (K), R48.1; also elsewhere on the board
/PWM2: D29.1 (K), R49.1; also elsewhere on the board
/PWM3: D30.1 (K), R50.1; also elsewhere on the board
GND: D27.2 (A), D28.2 (A), D29.2 (A), D30.2 (A); also elsewhere on the board

Notes on the sheet:
Just protect from surges and limit output current PWM Logic level will be 3.3V

Schematic: INPUTS.kicad_sch

Parts:
C13, C14, C15, C16: 20n; C_0603_1608Metric
D9, D11, D13, D15, D17, D18, D19, D20: PTVS26VZ1USK; Nexperia_DSN1608-2_1.6x0.8mm
D10, D12, D14, D31: SZMM5Z3V3T1G; D_SOD-523
R11, R12, R13, R14, R19, R20, R21, R22: 10k; R_0603_1608Metric
R15, R16, R17, R18: 0R; R_0603_1608Metric
R23, R24, R25, R26: 1K; R_0603_1608Metric
U5: LM324; SOIC-14_3.9x8.7mm_P1.27mm

Connections:
+3.3V: U5.4 (V+); also elsewhere on the board
/AIN0: D17.1 (K), R15.1; also elsewhere on the board
/AIN1: D18.1 (K), R16.1; also elsewhere on the board
/AIN2: D19.1 (K), R17.1; also elsewhere on the board
/AIN3: D20.1 (K), R18.1; also elsewhere on the board
/DIN0: D9.1 (K), R11.1; also elsewhere on the board
/DIN1: D11.1 (K), R12.1; also elsewhere on the board
/DIN2: D13.1 (K), R13.1; also elsewhere on the board
/DIN3: D15.1 (K), R14.1; also elsewhere on the board
/INPUTS/A0: C13.1, R23.2; also elsewhere on the board
/INPUTS/A1: C14.1, R24.2; also elsewhere on the board
/INPUTS/A2: C15.1, R25.2; also elsewhere on the board
/INPUTS/A3: C16.1, R26.2; also elsewhere on the board
/INPUTS/D0: D14.1 (K), R11.2; also elsewhere on the board
/INPUTS/D1: D12.1 (K), R12.2; also elsewhere on the board
/INPUTS/D2: D10.1 (K), R13.2; also elsewhere on the board
/INPUTS/D3: D31.1 (K), R14.2; also elsewhere on the board
GND: C13.2, C14.2, C15.2, C16.2, D9.2 (A), D10.2 (A), D11.2 (A), D12.2 (A), D13.2 (A), D14.2 (A), D15.2 (A), D17.2 (A), D18.2 (A), D19.2 (A), D20.2 (A), D31.2 (A), R19.2, R20.2, R21.2, R22.2, U5.11 (V-); also elsewhere on the board
unnamed: R15.2, R19.1, U5.3 (+)
unnamed: R23.1, U5.1, U5.2 (-)
unnamed: R16.2, R20.1, U5.5 (+)
unnamed: R24.1, U5.6 (-), U5.7
unnamed: R17.2, R21.1, U5.10 (+)
unnamed: R25.1, U5.8, U5.9 (-)
unnamed: R18.2, R22.1, U5.12 (+)
unnamed: R26.1, U5.13 (-), U5.14

Notes on the sheet:
With This circuit you can ensure operation at a whole range of input voltage, zener current clamps to archieve desired voltage.
DIGITAL INPUTS
Inputs Digitales reguladas por diodo Zener
ANALOG INPUTS
Filters Calculated for a 5khz lowpass antialias, antinoise filter, mainly for reading sensors at human freq.

Schematic: RELAY.kicad_sch

Parts:
D6: SS14; D_SOD-123
K2: G5Q-1; Relay_SPDT_Omron-G5Q-1
Q5: ZXMN3F30FH; SOT-23
R51: 10k; R_0603_1608Metric
R52: 6R; R_0603_1608Metric

Connections:
+24V: D6.1 (K), K2.5; also elsewhere on the board
/MICRO_F4/SC_EN: R51.2, R52.1; also elsewhere on the board
/SC_IN: K2.2; also elsewhere on the board
/SC_OUT: K2.3; also elsewhere on the board
GND: Q5.2 (S), R51.1; also elsewhere on the board
unnamed: D6.2 (A), K2.1, Q5.3 (D)
unnamed: Q5.1 (G), R52.2

Notes on the sheet:
El diodo proteje el mosfet del sobrevoltaje que se da al dejar de suministrar la corriente a la bobina.
El peak insrush current de los coils de los AIR es 3.8Amps luego el switch current del relé debería ser capáz de soportarlos. Este lo hace
La resistencia de puerta regula la carga del gate del mosfet para no exigir sobrecorrientes al micro, la otra es una resistencia de pulldown.

Schematic: POWER.kicad_sch

Parts:
C9, C10: 10 µF; C_0805_2012Metric
C11, C12: 10u; C_0603_1608Metric
F1: 500mA; Fuse_1210_3225Metric
L1: TCK-141; L_TracoPower_TCK-141
U3: TSR_1-2450; Converter_DCDC_TRACO_TSR-1_THT
U4: LM1117MP-3.3; SOT-223-3_TabPin2

Connections:
24_VIN: F1.1; also elsewhere on the board
+3.3V: C12.1, U4.2 (VO); also elsewhere on the board
+5V: C11.1, U3.3 (Vout), U4.3 (VI); also elsewhere on the board
+24V: C9.1, F1.2, L1.2; also elsewhere on the board
GND: C9.2, C10.2, C11.2, C12.2, U3.2 (GND), U4.1 (GND); also elsewhere on the board
unnamed: C10.1, L1.1, U3.1 (Vin)

Notes on the sheet:
5V->3.3V Linear Regulator
24V->5V Buck Converter (Caution Ripple)
Fused Power Input
Habría que hacer calculos/experimental de consumo placa
En principio alimentación general de todo lo que no sean los sensores
Mirar emi_consideration.pdf

Schematic: USB.kicad_sch

Parts:
D16: SS14; D_SOD-123
J4: USB_B_Mini; USB_Mini-B_Wuerth_65100516121_Horizontal
U7: USBLC6-2SC6; SOT-23-6

Connections:
+5V: D16.1 (K), U7.5 (VBUS); also elsewhere on the board
/MICRO_F4/USB_D+: U7.1 (I/O1); also elsewhere on the board
/MICRO_F4/USB_D-: U7.3 (I/O2); also elsewhere on the board
/USB/D+: J4.3 (D+), U7.6 (I/O1)
/USB/D-: J4.2 (D-), U7.4 (I/O2)
GND: J4.5 (GND), J4.6 (Shield), U7.2 (GND); also elsewhere on the board
unnamed: D16.2 (A), J4.1 (VBUS)

Notes on the sheet:
Este input USB puede proveer de actualizaciones de firm por usb con el sw de fabrica y una salida de SL-CAN
VCOM SERIAL PORT (SLCAN)
